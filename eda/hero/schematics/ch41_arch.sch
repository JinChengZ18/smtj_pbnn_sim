v {xschem version=3.4.4 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
L 4 40 250 200 250 {}
L 4 200 250 200 350 {}
L 4 200 350 40 350 {}
L 4 40 350 40 250 {}
L 4 260 220 460 220 {}
L 4 460 220 460 390 {}
L 4 460 390 260 390 {}
L 4 260 390 260 220 {}
L 4 520 220 740 220 {}
L 4 740 220 740 390 {}
L 4 740 390 520 390 {}
L 4 520 390 520 220 {}
L 4 800 215 1020 215 {}
L 4 1020 215 1020 395 {}
L 4 1020 395 800 395 {}
L 4 800 395 800 215 {}
L 4 1080 220 1290 220 {}
L 4 1290 220 1290 390 {}
L 4 1290 390 1080 390 {}
L 4 1080 390 1080 220 {}
L 4 520 470 740 470 {}
L 4 740 470 740 560 {}
L 4 740 560 520 560 {}
L 4 520 560 520 470 {}
L 4 1190 478 1300 478 {}
L 4 1300 478 1300 552 {}
L 4 1300 552 1190 552 {}
L 4 1190 552 1190 478 {}
T {stochastic} 70 290 0 0 0.24 0.24 {}
T {input  x(r)} 70 314 0 0 0.24 0.24 {}
T {2T SOT-MTJ} 300 246 0 0 0.24 0.24 {}
T {XNOR-CIM array} 290 270 0 0 0.24 0.24 {}
L 4 308 322 332 322 {}
L 4 332 322 332 338 {}
L 4 332 338 308 338 {}
L 4 308 338 308 322 {}
L 4 305 334 335 326 {}
L 4 320 322 320 310 {}
L 4 320 338 320 350 {}
L 4 388 322 412 322 {}
L 4 412 322 412 338 {}
L 4 412 338 388 338 {}
L 4 388 338 388 322 {}
L 4 385 334 415 326 {}
L 4 400 322 400 310 {}
L 4 400 338 400 350 {}
T {I_col ~ S XNOR(x,w)} 282 374 0 0 0.18 0.18 {}
T {slope-matched} 560 244 0 0 0.24 0.24 {}
T {read-out} 560 268 0 0 0.24 0.24 {}
T {R_TI + StrongARM} 548 300 0 0 0.2 0.2 {}
T {(p-bit decision)} 556 322 0 0 0.18 0.18 {}
T {| column-shared SAR} 548 350 0 0 0.2 0.2 {}
T {(reservoir)} 568 372 0 0 0.18 0.18 {}
T {probability mapper} 820 240 0 0 0.22 0.22 {}
T {+ write path:} 820 264 0 0 0.22 0.22 {}
T {R-string write-DAC} 820 300 0 0 0.2 0.2 {}
T {IR pre-distortion} 820 330 0 0 0.2 0.2 {}
T {CMOS write driver} 820 360 0 0 0.2 0.2 {}
T {stochastic SOT-MTJ} 1100 244 0 0 0.22 0.22 {}
T {sampling array} 1110 268 0 0 0.22 0.22 {}
L 4 1138 322 1162 322 {}
L 4 1162 322 1162 338 {}
L 4 1162 338 1138 338 {}
L 4 1138 338 1138 322 {}
L 4 1135 334 1165 326 {}
L 4 1150 322 1150 310 {}
L 4 1150 338 1150 350 {}
L 4 1218 322 1242 322 {}
L 4 1242 322 1242 338 {}
L 4 1242 338 1218 338 {}
L 4 1218 338 1218 322 {}
L 4 1215 334 1245 326 {}
L 4 1230 322 1230 310 {}
L 4 1230 338 1230 350 {}
T {(thermal switching)} 1105 374 0 0 0.18 0.18 {}
T {expectation averaging} 540 504 0 0 0.22 0.22 {}
T {(T samples)} 575 530 0 0 0.2 0.2 {}
T {E[s]} 1218 522 0 0 0.3 0.3 {}
L 4 200 300 260 300 {}
L 4 250 295 260 300 {}
L 4 250 305 260 300 {}
T {x(r)} 208 290 0 0 0.18 0.18 {}
L 4 460 300 520 300 {}
L 4 510 295 520 300 {}
L 4 510 305 520 300 {}
T {I_col} 466 290 0 0 0.18 0.18 {}
L 4 740 305 800 305 {}
L 4 790 300 800 305 {}
L 4 790 310 800 305 {}
T {a} 760 295 0 0 0.18 0.18 {}
L 4 1020 305 1080 305 {}
L 4 1070 300 1080 305 {}
L 4 1070 310 1080 305 {}
T {write} 1026 295 0 0 0.18 0.18 {}
L 4 630 390 630 470 {}
L 4 625 460 630 470 {}
L 4 635 460 630 470 {}
T {T samples} 636 426 0 0 0.18 0.18 {}
L 4 740 515 1190 515 {}
L 4 1180 510 1190 515 {}
L 4 1180 520 1190 515 {}
L 4 1290 360 1340 360 {}
L 4 1340 360 1340 600 {}
L 4 1340 600 120 600 {}
L 4 120 600 120 350 {}
L 4 115 360 120 350 {}
L 4 125 360 120 350 {}
T {x(r+1)} 700 586 0 0 0.2 0.2 {}
T {sMTJ-PBNN closed-loop forward  (circuit-accurate architecture)} 300 150 0 0 0.26 0.26 {}
